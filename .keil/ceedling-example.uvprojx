# Keil uVision project ceedling-example.uvprojx, settings and files
target stm32f103c8 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ceedling-example +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=3
  c include: ..\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: button.c button.h calculator.c calculator.h main.c app.c retarget.c
  group tests
    ../test/: test_calculator.c
software components: CMSIS:CORE 5.6.0, Test:Unity 2.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
